Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2016-10-18T11:13:38
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 15.7.0.0 - Alternate UI 15.7.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Tue Oct 18 11:13:38 2016* Host: NCL-PI10* Database: C:\Users\TheriauC\AppData\Local\Temp\{00E6867F-061F-426F-9632-8FFCC391DA93}\ifc* Database version: 5507* Database creation date: Tue Oct 18 11:13:37 2016* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Tue Oct 18 11:13:37 2016* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Tue Oct 18 11:13:37 2016* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: X:\NBL\Manufacturer\P\Pineapple Contracts_27701\NBLA0652\Authoring\IFC\smile high.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFurnishingElement: HighBack, NBS_PineapleContracts_DmstcChrs_Smile_HighBack:HighBack:4871
In: Level 1
Type - Classification: E2020200 (Uniformat); Material: NBS_Concept
Type - NBS_General - Author: NBS; BIMObjectName: NBS_PineapleContracts_DomesticChairs_Smile_HighBack; ManufacturerName: Pineapple Contracts; ManufacturerURL: www.pineapplecontracts.com; NBSCertification: www.nationalbimlibrary.com/cert/mu05i1p0; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSTypeID: n/a; ProductInformation: www.pineapplecontracts.com/products/chairs/3/smile/254; Revision: n/a; Uniclass2015Title: Pr_40_50_12_71; Uniclass2015Code: Reception chairs; Uniclass2015Version: Products v1.3; Version: 1
Type - NBS_Data - SeatsAndBacksMaterial: Foam and cotton; SeatsAndBacksFinish: Fabric; SeatsAndBacksColour: n/a; FramesMaterial: Metal and plywood; FramesFinish: n/a; FramesColour: n/a; CountryOfOrigin: England; AssemblyRequired: Yes; FabricOptions: By request; SeatPlatform: BS EN 16139 2013; StrengthAndStability: BS EN 16139 2013; CoverOptions: By request; EnvironmentalProductDeclaration: n/a; FabricFireRating: Crib 5; Fabric: n/a; FramesFinishOptions: Powdercoated, stainless steel; FramesColourOptions: Black or stainless, custom colours available; SeatsAndBacksColourOptions: By request
Type - Pset_FurnitureTypeCommon - Description: Reception chair; MainColor: n/a; NominalDepth: 719 mm; NominalHeight: 1174 mm; NominalLength: 822 mm; Style: Office Chair
Type - Pset_FurnitureTypeChair - HighestSeatingHeight: 400 mm; LowestSeatingHeight: 363 mm; SeatingHeight: 390 mm
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Furniture; CodePerformance: BS EN 16139 2013; Color: n/a; Constituents: n/a; DurationUnit: year; ExpectedLife: 10; Features: Side wings, integrated armrest, solid steel rod legs; Finish: Fabric; Grade: n/a; Material: n/a; Manufacturer: sales@pineapplecontracts.com; ModelNumber: n/a; ModelReference: Smile high back; Name: DomesticChairs_Smile_HighBack_PineappleContracts; NominalWidth: 822 mm; ReplacementCost: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: 7; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Classification: Reception chairs (Uniclass2015); E2020200 (Uniformat)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
